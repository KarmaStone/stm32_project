# IAR project keyboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L452RE ST STM32L452RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L452xx
  ICCARM.IExtraOptions: -f ..\startup\keyboard\config.cfg
  ICCARM.CCIncludePath2: ..\startup\keyboard; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ..\Middlewares\private\list; ..\Middlewares\private\utilities; ..\Middlewares\private\priv_os; ..\Drivers\platform\serial; ..\application\shell_cmd; ..\registeredstart\init_d; ..\registeredstart\miscdevice; ..\registeredstart\register; ..\components\time; ..\components\cm_backtrace; ..\Drivers\platform\pwr_mng; ..\Drivers\platform\iwdg; ..\components\watchdog; ..\Drivers\platform\lpuart1; ..\components\sleep_time; ..\application\bt_task; ..\Drivers\platform\system_wakeup; ..\Drivers\platform\i2c; ..\Drivers\platform\io_irq; ..\Drivers\platform\spi; ..\Drivers\modules\flash\winbond; ..\Drivers\modules\flash; ..\components\nv_flash; ..\Middlewares\private\nv_list; ..\Middlewares\private\crc32; ..\components\password_list; ..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ..\components\ush_hid
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\startup
  OBJCOPY.OOCOutputFile: keyboard.hex
  ILINK.IlinkOutputFile: keyboard.out
  ILINK.IlinkIcfFile: ..\startup\keyboard\stm32l452xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group application/shell
    ../application/shell_cmd/: cmd_ls.c fputc_redirect.c shell_cmd.c shell_cmd.h
  group components/cm_backtrace
    ../components/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../components/cm_backtrace/fault_handler/iar/: cmb_fault.S
  group components/sleep_time
    ../components/sleep_time/: sleep_time.c sleep_time.h
  group components/time
    ../components/time/: time.c time.h
  group components/usb_hid
    ../components/ush_hid/: usb_device.c usb_device.h usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h user_diskio.c user_diskio.h
  group components/watchdog
    ../components/watchdog/: watchdog.c watchdog.h
  group drivers/hal_driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lptim.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_ll_crc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_rcc.c stm32l4xx_ll_usb.c
  group drivers/platform/pwr_mng
    ../Drivers/platform/pwr_mng/: pwr.c pwr.h
  group drivers/platform/serial
    ../Drivers/platform/serial/: com_port1.c com_port1.h com_port2.c com_port2.h serialx.c serialx.h
  group middlewares/freertos
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group middlewares/private/crc32
    ../Middlewares/private/crc32/: crc32.c crc32.h
  group middlewares/private/list
    ../Middlewares/private/list/: priv_list.c priv_list.h
  group middlewares/private/priv_os
    ../Middlewares/private/priv_os/: priv_os.c priv_os.h
  group middlewares/private/unit
    ../Middlewares/private/utilities/: errno.h unit.c unit.h
  group middlewares/usb_hid
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group registeredstart/init_d
    ../registeredstart/init_d/: init_d.c init_d.h
  group registeredstart/miscdevice
    ../registeredstart/miscdevice/: major.h miscdevice.c miscdevice.h
  group registeredstart/register
    ../registeredstart/register/: platform_register.c platform_register.h
  group startup
    ../startup/keyboard/: config.cfg FreeRTOSConfig.h main.c startup.h startup_stm32l452xx.s stm32_clock.c stm32l452xx_flash.icf stm32l4xx_hal_conf.h stm32l4xx_hal_msp.c stm32l4xx_it.c stm32l4xx_it.h system_stm32l4xx.c version.h
