<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\keyboard.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lock.ewp</path>
    </project>
    <batchBuild />
</workspace>
