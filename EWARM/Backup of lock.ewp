# IAR project Backup of lock.ewp, settings and files
configuration lock (ARM, debug)
  General.OGChipSelectEditMenu: STM32L471RE ST STM32L471RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L471xx
  ICCARM.IExtraOptions: -f ..\startup\config.cfg
  ICCARM.CCIncludePath2: ..\startup; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ..\Middlewares\private\list; ..\Middlewares\private\utilities; ..\Middlewares\private\priv_os; ..\Drivers\platform\serial; ..\application\shell_cmd; ..\registeredstart\init_d; ..\registeredstart\miscdevice; ..\registeredstart\register; ..\components\time; ..\components\cm_backtrace; ..\Drivers\platform\pwr_mng; ..\Drivers\platform\iwdg; ..\components\watchdog; ..\Drivers\platform\lpuart1; ..\components\sleep_time; ..\application\bt_task; ..\Drivers\platform\system_wakeup; ..\Drivers\platform\i2c; ..\Drivers\platform\io_irq; ..\Drivers\platform\spi; ..\Drivers\modules\flash\winbond; ..\Drivers\modules\flash; ..\components\nv_flash; ..\Middlewares\private\nv_list; ..\Middlewares\private\crc32; ..\components\password_list
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\startup
  OBJCOPY.OOCOutputFile: lock.hex
  ILINK.IlinkOutputFile: lock.out
  ILINK.IlinkIcfFile: stm32l471xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application/bt_task
    ../application/bt_task/: bt_task.c bt_task.h
  group application/finger_task
    ../application/finger/: finger_task.c finger_task.h
  group application/keyboard
    ../application/kb_task/: kb_task.c kb_task.h menu_item.c
  group application/shell_cmd
    ../application/shell_cmd/: cmd_ls.c cmd_pwd.c fputc_redirect.c shell_cmd.c shell_cmd.h
  group components/cm_backtrace
    ../components/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../components/cm_backtrace/fault_handler/iar/: cmb_fault.S
  group components/nv_flash
    ../components/nv_flash/: nv_flash.c nv_flash.h
  group components/password_list
    ../components/password_list/: password_list.c password_list.h
  group components/sleep_time
    ../components/sleep_time/: sleep_time.c sleep_time.h
  group components/time
    ../components/time/: time.c time.h
  group components/watchdog
    ../components/watchdog/: watchdog.c watchdog.h
  group drivers/hal_driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lptim.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_crc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_rcc.c
  group drivers/modules/flash
    ../Drivers/modules/flash/: flash_type.h
  group drivers/modules/flash/winbond
    ../Drivers/modules/flash/winbond/: wbf_8M.c wbf_8M.h
  group drivers/modules/touch_keyboard
    ../Drivers/modules/touch_keyboard/: touch_keyboard.c touch_keyboard.h
  group drivers/platform/i2c
    ../Drivers/platform/i2c/: i2c1.c i2c1.h i2c_type.h i2c_unit.c
  group drivers/platform/IO_IRQ
    ../Drivers/platform/io_irq/: io_irq_line7.c io_irq_line7.h
  group drivers/platform/iwdg
    ../Drivers/platform/iwdg/: iwdg.c iwdg.h
  group drivers/platform/LPTIM1
    ../Drivers/platform/lptim1/: lptim.c lptim.h
  group drivers/platform/lpuart1
    ../Drivers/platform/lpuart1/: lpuart1.c lpuart1.h
  group drivers/platform/pwr_mng
    ../Drivers/platform/pwr_mng/: pwr.c pwr.h
  group drivers/platform/rtc/stm32l4xx
    ../Drivers/platform/rtc/stm32l4/: stm32l4_rtc.c stm32l4_rtc.h
  group drivers/platform/serial
    ../Drivers/platform/serial/: serial1.c serial1.h serial5.c serial5.h
  group drivers/platform/spi
    ../Drivers/platform/spi/: spi1.c spi1.h
  group drivers/platform/system_wakeup
    ../Drivers/platform/system_wakeup/: syswakeup1.c syswakeup1.h syswakeup2.c syswakeup2.h syswakeup4.c syswakeup4.h syswakeup5.c syswakeup5.h
  group middlewares/freertos
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group middlewares/private/crc32
    ../Middlewares/private/crc32/: crc32.c crc32.h
  group middlewares/private/list
    ../Middlewares/private/list/: priv_list.c priv_list.h
  group middlewares/private/nv_list
    ../Middlewares/private/nv_list/: nv_list.c nv_list.h
  group middlewares/private/priv_os
    ../Middlewares/private/priv_os/: priv_os.c priv_os.h
  group middlewares/private/unit
    ../Middlewares/private/utilities/: unit.c unit.h
  group registeredstart/init_d
    ../registeredstart/init_d/: init_d.c init_d.h
  group registeredstart/miscdevice
    ../registeredstart/miscdevice/: major.h miscdevice.c miscdevice.h
  group registeredstart/register
    ../registeredstart/register/: platform_register.c platform_register.h
  group startup
    ../startup/: config.cfg FreeRTOSConfig.h main.c startup.h stm32_clock.c stm32l4xx_hal_conf.h stm32l4xx_hal_msp.c stm32l4xx_it.c stm32l4xx_it.h system_stm32l4xx.c version.h
    ./: startup_stm32l471xx.s stm32l471xx_flash.icf
